# Keil uVision project STM32F0_Discovery_TEST.uvprojx, settings and files
target STM32F030R8T6 (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: STM32F0_Discovery_TEST +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0xx_HD
  c include: .\FreeRTOS\include;.\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\Board_Task;.\Common\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c port.c
    ./FreeRTOS/MemMang/: heap_2.c
  group Libraries
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Task
    ./Board_Task/: main.c stm32f0_discovery.c stm32f0xx_it.c system_stm32f0xx.c user_tasks.c lcd.c
  group ::CMSIS
    E:/Keil_v5/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS/Lib/ARM/: arm_cortexM0l_math.lib
  group ::Device
    RTE/Device/STM32F030R8/: startup_stm32f030.s system_stm32f0xx.c
software components: CMSIS:CORE 3.20.0, CMSIS:DSP 1.4.1, Device:Startup 1.0.0
